# Keil uVision project IOBoard.uvprojx, settings and files
target IOBoard (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IOBoard
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\GD\GD32F10x\Include;..\Library\GD32F10x_standard_peripheral\Include;..\User\APP\Includes;..\User\BSP\Includes;..\Library\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Peripheral
    ../Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group CMSIS
    ../Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Startup
    ../Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group BSP
    ../User/BSP/Sources/: gd32f10x_it.c
  group App
    ../User/APP/Sources/: main.c systick.c
